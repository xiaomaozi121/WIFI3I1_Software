# IAR project test.ewp, settings and files
configuration Library (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: dlArmCustom.h
  ICCARM.CCDefines: _SYSTEM_BUILD
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\lib\dlib\; $TOOLKIT_DIR$\src\lib\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Test2.srec
  ILINK.IlinkOutputFile: Test2.out
  group (top)
    ./: dlArmCustom.h Readme.txt
  group DLib generic
    $EW_DIR$/arm/src/lib/dlib/: abs.c abs_l.cpp abs_t.cpp asctime.c atexit.c atexit2.cpp atoi.c atol.c atoll.c bad_alloc.cpp bad_exception.cpp bsearch.c bsearch2.cpp btowc.c c16rtomb.c c32rtomb.c callnewh.cpp calloc.c clearerr.c ctime.c ctime64.c ctime_i.c ctype.c cxabad.cpp cxxabi.cpp cxxabiguard.cpp delaop2_0.cpp delaop2_1.cpp delaop2_2.cpp delaop2_3.cpp delaop2_4.cpp delaop3.cpp delaop_0.cpp delaop_1.cpp delaop_2.cpp delaop_3.cpp delaop_4.cpp delop2_0.cpp delop2_1.cpp delop2_2.cpp delop2_3.cpp delop2_4.cpp delop3.cpp delop_0.cpp delop_1.cpp delop_2.cpp delop_3.cpp delop_4.cpp difftime_i.c div.c div_l.cpp div_t.cpp errno.c exception.cpp fclose.c fdopen.c feof.c ferror.c fflush.c fgetc.c fgetpos.c fgets.c fgetwc.c fgetws.c fileno.c fiopen.cpp fopen.c fprintf.c fputc.c fputs.c fputwc.c fputws.c fread.c free.c freopen.c fscanf.c fseek.c fsetpos.c ftell.c fwide.c fwprintf.c fwrite.c fwscanf.c getc.c getchar.c gets.c getw.c getwc.c getwchar.c getzone.c gmtime.c gmtime64.c gmtime_i.c imaxabs.c imaxdiv.c __dbg_mem.c iomanip.cpp ios.cpp iostream.cpp iostream_cerr.cpp iostream_cin.cpp iostream_cout.cpp isalnum.c isblank.c isdigit.c isgraph.c isprint.c iswalnum.c iswblank.c iswgraph.c iswprint.c iswxxx.c isxdigit.c isxxx.c labs.c ldiv.c limits.c limits2.cpp llabs.c lldiv.c locale.cpp locale0.cpp localeconv.c localtim.c localtim64.c localtim_i.c malloc.c mblen.c mbrlen.c mbrtoc16.c mbrtoc32.c mbrtowc.c mbsinit.c mbsrtowc.c mbstowcs.c mbtowc.c memchr2.cpp memchr3.cpp memcpy.c memset.c mktime.c mktime64.c mktime_i.c new.cpp newaop2_0.cpp newaop2_1.cpp newaop2_2.cpp newaop2_3.cpp newaop2_4.cpp newaop_0.cpp newaop_1.cpp newaop_2.cpp newaop_3.cpp newaop_4.cpp newop2_0.cpp newop2_1.cpp newop2_2.cpp newop2_3.cpp newop2_4.cpp newop_0.cpp newop_1.cpp newop_2.cpp newop_3.cpp newop_4.cpp nomemory.cpp nothrow.cpp perror.c printf.c putc.c putchar.c puts.c putw.c putwc.c putwchar.c qsort.c qsort2.cpp qsortbbl.c rand.c realloc.c rewind.c rtti.cpp rtti2.cpp scanf.c setbuf.c setlocale.c setvbuf.c signaldefs.c snprintf.c sprintf.c srand.c sscanf.c stdlib.c strcasecmp.c strcat.c strchr2.cpp strchr3.cpp strcoll.c strcspn.c strdup.c strerror.c strftime.c string.cpp strncasecmp.c strncat.c strncmp.c strnlen.c strpbrk.c strpbrk2.cpp strpbrk3.cpp strrchr.c strrchr2.cpp strrchr3.cpp strspn.c strstr.c strstr2.cpp strstr3.cpp strstrea.cpp strtoimax.c strtok.c strtok_r.c strtol.c strtoll.c strtoul.c strtoull.c strtoumax.c strxfrm.c swprintf.c swscanf.c throw.cpp time_i.c timeconst.c tmpfile.c tmpnam.c tolower.c toupper.c towctran.c towlower.c towupper.c typeinfo.cpp ungetc.c ungetwc.c vars.cpp vec_newdel.cpp vfprintf.c vfscanf.c vfwprint.c vfwscanf.c vla_alloc.c vprintf.c vscanf.c vsnprint.c vsprintf.c vsscanf.c vswprint.c vswscanf.c vwprintf.c vwscanf.c wcrtomb.c wcscat.c wcschr.c wcschr2.cpp wcschr3.cpp wcscmp.c wcscoll.c wcscpy.c wcscspn.c wcsftime.c wcslen.c wcsncat.c wcsncmp.c wcsncpy.c wcspbrk.c wcspbrk2.cpp wcspbrk3.cpp wcsrchr.c wcsrchr2.cpp wcsrchr3.cpp wcsrtomb.c wcsspn.c wcsstr.c wcsstr2.cpp wcsstr3.cpp wcstoimax.c wcstok.c wcstol.c wcstoll.c wcstombs.c wcstoul.c wcstoull.c wcstoumax.c wcsxfrm.c wctob.c wctomb.c wctrans.c wctype.c wiostrea.cpp wlocale.cpp wmemchr.c wmemchr2.cpp wmemchr3.cpp wmemcmp.c wmemcpy.c wmemmove.c wmemset.c wprintf.c wscanf.c xassert.c xbtowc.c xcloseall.c xcostate.c xencoding_sb.c xencoding_utf8.c xexit.c xferaise.c xfgpos.c xfiles.c xfofind.c xfopen.c xfoprep.c xfprout.c xfrprep.c xfscin.c xfspos.c xfwprep.c xgentime.c xgetdst.c xgetglob.c xgetmemchunk.c xgetptime.c xgettime.c xiar.c xisdst.c xisdst64.c xisdstData.c xlibrary_version.c xlocale.cpp xlocale_POSIX.c xlocale_c.c xlocale_cs_CZ.c xlocale_da_DK.c xlocale_da_EU.c xlocale_de_AT.c xlocale_de_BE.c xlocale_de_CH.c xlocale_de_DE.c xlocale_de_EU.c xlocale_de_LU.c xlocale_el_EU.c xlocale_el_GR.c xlocale_en_AU.c xlocale_en_CA.c xlocale_en_EU.c xlocale_en_GB.c xlocale_en_IE.c xlocale_en_NZ.c xlocale_en_US.c xlocale_es_AR.c xlocale_es_BO.c xlocale_es_CL.c xlocale_es_CO.c xlocale_es_DO.c xlocale_es_EC.c xlocale_es_ES.c xlocale_es_EU.c xlocale_es_GT.c xlocale_es_HN.c xlocale_es_MX.c xlocale_es_PA.c xlocale_es_PE.c xlocale_es_PY.c xlocale_es_SV.c xlocale_es_US.c xlocale_es_UY.c xlocale_es_VE.c xlocale_et_EE.c xlocale_eu_ES.c xlocale_fi_EU.c xlocale_fi_FI.c xlocale_fo_FO.c xlocale_fr_BE.c xlocale_fr_CA.c xlocale_fr_CH.c xlocale_fr_EU.c xlocale_fr_FR.c xlocale_fr_LU.c xlocale_ga_EU.c xlocale_ga_IE.c xlocale_gl_ES.c xlocale_hr_HR.c xlocale_hu_HU.c xlocale_id_ID.c xlocale_is_EU.c xlocale_is_IS.c xlocale_it_EU.c xlocale_it_IT.c xlocale_iw_IL.c xlocale_kl_GL.c xlocale_lt_LT.c xlocale_lv_LV.c xlocale_nl_BE.c xlocale_nl_EU.c xlocale_nl_NL.c xlocale_no_EU.c xlocale_no_NO.c xlocale_pl_PL.c xlocale_pt_BR.c xlocale_pt_EU.c xlocale_pt_PT.c xlocale_ro_RO.c xlocale_ru_RU.c xlocale_sl_SI.c xlocale_sv_EU.c xlocale_sv_FI.c xlocale_sv_SE.c xlocale_tr_TR.c xlocinfo.cpp xlocnum_get.cpp xlocnum_put_d.cpp xlocnum_put_etc.cpp xlocnum_put_f.cpp xlocnum_put_lld.cpp xmbcurmax.c xmbtowc.c xmutex.cpp xprintassert.c xprintfdefault.c xprintfdefault_nomb.c xprintffull.c xprintffull_nomb.c xprintflarge.c xprintflarge_nomb.c xprintfsmall.c xprintfsmall_nomb.c xprintftiny.c xprout.c xpurevirtual.c xreportassert.c xscanfdefault.c xscanfdefault_nomb.c xscanffull.c xscanffull_nomb.c xscanflarge.c xscanflarge_nomb.c xscanfsmall.c xscanfsmall_nomb.c xscin.c xsnprout.c xsprout.c xsscin.c xstldebugging.cpp xstoflt.c xstol.c xstoll.c xstopfx.c xstoul.c xstoull.c xstoxflt.c xstrerro.c xstrftim.c xstrxfrm.c xsyslock.c xsyslock_mtx.c xsyslock_nop.c xthreads.c xthrow_no_throw.cpp xthrow_throw.cpp xtls.c xtowctrans.c xttotm.c xttotm64.c xwcostate.c xwcsftim.c xwcsxfrm.c xwctob.c xwctomb.c xwctype.c xwfprout.c xwfrprep.c xwfscin.c xwfwprep.c xwgenld.c xwgetfld.c xwgetflo.c xwgetint.c xwgetstr.c xwldtob.c xwlitob.c xwprintf.c xwprout.c xwputfld.c xwputstr.c xwputtxt.c xwscanf.c xwscin.c xwsprout.c xwsscin.c xwstoflt.c xwstoll.c xwstopfx.c xwstoul.c xwstoull.c xwstoxfl.c xxgets.c xxmemxcalloc.c xxmemxfree.c xxmemxmalloc.c xxmemxmemcpy.c xxmemxmemmove.c xxmemxmemzero.c xxwcspbrk.c xxwcsrchr.c xxwcsstr.c xxwrite_array.c xxwritebuffered.c cppinit.c environ.c getenv.c
    $EW_DIR$/arm/src/lib/semihosting/: XShHandles.c XShttio.c
  group Low-level interface
    ./: abort.c clock.c dlmalloc.c dlmalloc_stat.c exit.c raise.c signal.c system.c time.c time64.c low_level_init.c
