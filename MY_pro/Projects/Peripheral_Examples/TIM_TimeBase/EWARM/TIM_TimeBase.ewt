<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>TIM_TimeBase</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Source\Templates\iar\startup_stm32f030x8.s</name>
    </file>
  </group>
  <group>
    <name>STM32F0xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_usart.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32f0xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\system_stm32f0xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\userBSP.c</name>
    </file>
  </group>
  <group>
    <name>wifi_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\json_data_sendmakd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_ascii.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_check_ipset.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_check_link.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_check_tcplk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_config_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_connect_ap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_creat_apadhoc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_easyconfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_en_dis_tcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_query_con_status.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_query_dns.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_query_fwversion.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_query_ipconfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_query_rssi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_reld_mudol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_scan_ap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_send_data.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_set_channel.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_set_ipdhcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_set_ipstatic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_set_psk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_set_pwrmode.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_set_sipinfo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_set_webconfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_start_autoconnect.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_start_webconfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_storeconfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_tcp_send_recv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_WIFI_Driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\WIFI_Driver\wifi_wps.c</name>
    </file>
  </group>
</project>


