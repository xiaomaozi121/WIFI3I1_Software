# IAR project TIM_TimeBase.ewp, settings and files
configuration TIM_TimeBase (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; E:\BHKS\stm32f0\MY_DEMO\MY_pro\Projects\Peripheral_Examples\TIM_TimeBase; E:\BHKS\stm32f0\MY_DEMO\MY_pro\Projects\Peripheral_Examples\TIM_TimeBase; E:\BHKS\stm32f0\MY_DEMO\MY_pro\Projects\Peripheral_Examples\TIM_TimeBase\WIFI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIM_TimeBase.srec
  ILINK.IlinkOutputFile: TIM_TimeBase.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030x8.s
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_tim.c stm32f0xx_usart.c
  group User
    ../: main.c stm32f0xx_it.c system_stm32f0xx.c userBSP.c
  group wifi_Driver
    ../WIFI_Driver/: json_data_sendmakd.c wifi_ascii.c wifi_check_ipset.c wifi_check_link.c wifi_check_tcplk.c wifi_config_init.c wifi_connect_ap.c wifi_creat_apadhoc.c wifi_easyconfig.c wifi_en_dis_tcp.c wifi_query_con_status.c wifi_query_dns.c wifi_query_fwversion.c wifi_query_ipconfig.c wifi_query_rssi.c wifi_reld_mudol.c wifi_scan_ap.c wifi_send_data.c wifi_set_channel.c wifi_set_ipdhcp.c wifi_set_ipstatic.c wifi_set_psk.c wifi_set_pwrmode.c wifi_set_sipinfo.c wifi_set_webconfig.c wifi_start_autoconnect.c wifi_start_webconfig.c wifi_storeconfig.c wifi_tcp_send_recv.c wifi_WIFI_Driver.c wifi_wps.c
