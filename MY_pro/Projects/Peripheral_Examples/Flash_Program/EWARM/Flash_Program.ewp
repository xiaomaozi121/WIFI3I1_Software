# IAR project Flash_Program.ewp, settings and files
configuration Flash_Program (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F0308-Discovery; E:\BHKS\stm32f0\MY_DEMO\MY_pro\Projects\Peripheral_Examples\TIM_TimeBase
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flash_Program.bin
  ILINK.IlinkOutputFile: Flash_Program.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030x8.s
  group STM32F0308-Discovery
    ../../../../Utilities/STM32F0308-Discovery/: stm32f0308_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c
  group User
    ../: main.c stm32f0xx_it.c system_stm32f0xx.c
