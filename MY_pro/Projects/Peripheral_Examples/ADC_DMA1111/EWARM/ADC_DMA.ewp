# IAR project ADC_DMA.ewp, settings and files
configuration ADC_DMA (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F0308-Discovery; E:\BHKS\stm32f0\MY_DEMO\MY_pro\Projects\Peripheral_Examples\ADC_DMA; E:\BHKS\stm32f0\MY_DEMO\MY_pro\Projects\Peripheral_Examples\ADC_DMA\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_DMA.srec
  ILINK.IlinkOutputFile: ADC_DMA.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: transplant_not.txt
  group AIR_Instrm
    ../src/: app.c dht11.c ds1302.c ht1621.c
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030x8.s
  group STM32F0308-Discovery
    ../../../../Utilities/STM32F0308-Discovery/: stm32f0308_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c
  group User
    ../: eeprom.c main.c stm32f0xx_it.c system_stm32f0xx.c userBSP.c
